# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Timer0.c Timer0.h key.c key.h LCD1602.c LCD1602.h
    ../6.2 矩阵键盘电子密码锁(项目)/: Delay.c Delay.h
